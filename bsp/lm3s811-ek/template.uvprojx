# Keil uVision project template.uvprojx, settings and files
target RT-Thread-lm3s (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LM3S811 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lm3s811 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: applications;.;drivers;Libraries;..\..\include;..\..\libcpu\arm\cortex-m3;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\finsh
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
--keep *.o(.rti_fn.*)  
--keep *.o(FSymTab) 
#--keep *.o(VSymTab)
  group Applications
    ./applications/: cpuports.c main.c uarts.c
    ./RTE/RTOS/: board.c
    ./RTE/Device/LM3S811/: Startup.s
  group Drivers
    ./drivers/: board.c serial.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
