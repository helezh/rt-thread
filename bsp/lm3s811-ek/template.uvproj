# Keil uVision project template.uvproj, settings and files
target RT-Thread-lm3s (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-lm3s
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: uC99=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler --keep *.o(.rti_fn.*) --keep *.o(FSymTab) --keep *.o(VSymTab)
