# Keil uVision project project.uvproj, settings and files
target rtthread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: S3C2416 Samsung
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0x00000000-0x00007FFF) CPUTYPE(ARM926EJ-S)
  output: rt_thread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RT_USING_ARM_LIBC
  c include: applications;.;drivers;platform;..\..\include;..\..\libcpu\arm\arm926;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\armlibc
  asm include: .\platform
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x10000
  scatter file: .\link_scripts\N32903.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c main.c startup.c
    ./: rtconfig.h
  group Drivers
    drivers/: board.c uarts.c led.c
  group platform
    platform/: interrupt.c reset.c rt_low_level_init.c system_clock.c timer0.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group ARM926
    ../../libcpu/arm/arm926/: cpuport.c mmu.c stack.c trap.c context_rvds.S start_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c time.c
