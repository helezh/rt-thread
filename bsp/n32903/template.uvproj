# Keil uVision project template.uvproj, settings and files
target rtthread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: rt_thread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\rt-thread\src\rt-thread\bsp\n32903\platform
  asm include: .\platform
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\link_scripts\N32903.sct
  link misc: #--entry Reset_Go --entry Entry_Point --keep *.o(.rti_fn.*) --keep *.o(FSymTab) --keep *.o(VSymTab)
